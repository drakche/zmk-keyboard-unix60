## boards/shields/unix60/Kconfig.defconfig
```kconfig
if SHIELD_UNIX60

config ZMK_KEYBOARD_NAME
    default "Unix60"

endif # SHIELD_UNIX60
```
